# Repository agmlego/water-cooling-controller

File README.md:

External Water-Cooling Loop Controller
--------------------------------------

The intent of this project is to monitor and control an external chiller system for a PC water-cooling loop with a liquid-liquid heat exchanger to separate the internal and external loops.

There is a PCIe x1 card inside the PC, tapping into SMBus and +3V3AUX, to monitor the flow, inlet, and outlet temperatures for the internal and external loops, and intercept the front panel power switch to prevent boot or to initiate a shutdown if the loops are not working correctly. The Teensy 3.2 will communicate to the PC, pretending to be a common SMBus device such as those from Winbond or Nuvoton. It also talks with an external board in the chiller over CAN. Onboard WS2811B and an OLED screen show immediate diagnostics. An onboard BME280 lets the Teensy monitor internal case ambient temperature and humidity, to ensure that the chiller does not drop below the local dewpoint to prevent condensation.

The external board listens to CAN and adjusts the chiller's power state and setpoint. It also reports the local BME280 results and has an onboard OLED screen for system status.

## Internal PCIe Card

| Pin | Type    | Signal | Direction | Purpose                                      |
| --- | ------- | ------ | --------- | -------------------------------------------- |
| 1   | POWER   | GND    |           | Digital ground plane                         |
| 2   | DIGITAL | D0     | INPUT     | Internal loop flow sensor                    |
| 3   | DIGITAL | D1     | INPUT     | External loop flow sensor                    |
| 4   | DIGITAL | D2     | OUTPUT    | CAN standby, active high                     |
| 5   | CAN     | TX     | OUTPUT    | CAN transmit                                 |
| 6   | CAN     | RX     | INPUT     | CAN receive                                  |
| 7   | DIGITAL | D5     | OUTPUT    | Level shifter output enable, active low      |
| 8   | DIGITAL | D6     | INPUT     | PCIe #PERST status                           |
| 9   | DIGITAL | D7     | OUTPUT    | WS2811B data                                 |
| 21  | ANALOG  | A0     | INPUT     | External loop outflow temperature, 10k   NTC |
| 22  | ANALOG  | A1     | INPUT     | External loop inflow temperature, 10k NTC    |
| 23  | ANALOG  | A2     | INPUT     | Internal loop inflow temperature, 10k   NTC  |
| 24  | ANALOG  | A3     | INPUT     | Internal loop outflow temperature, 10k NTC   |
| 25  | I2C     | SDA0   | BIDI      | SMBus I2C data                               |
| 26  | I2C     | SCL0   | BIDI      | SMBus I2C clock                              |
| 29  | DIGITAL | D22    | OUTPUT    | Front panel power switch output              |
| 30  | DIGITAL | D23    | INPUT     | Front panel power switch input               |
| 31  | POWER   | 3V3    |           | 3.3V AUX input                               |
| 32  | POWER   | AGND   |           | Analog ground plane                          |
| 42  | POWER   | 3V3    |           | 3.3V AUX input                               |
| 46  | I2C     | SDA1   | BIDI      | Local I2C data                               |
| 47  | I2C     | SCL1   | BIDI      | Local I2C clock                              |
| 53  | POWER   | GND    |           | Digital ground plane                         |

### WS2811B

1. External loop temperature status
2. External loop flow status
3. Internal loop temperature status
4. Internal loop flow status

### CAN DE-9

0. Chassis earth
1. N/C
2. CAN_H
3. GND
4. N/C
5. Chassis earth
6. GND
7. CAN_H
8. N/C
9. +5V

## Chiller Controller

| Pin | Type    | Signal | Direction | Purpose                            |
| --- | ------- | ------ | --------- | ---------------------------------- |
| 1   | POWER   | GND    |           | Digital ground                     |
| 4   | 1-WIRE  | D2     | BIDI      | DS18B20 bus                        |
| 5   | CAN     | TX     | OUTPUT    | CAN transmit                       |
| 6   | CAN     | RX     | INPUT     | CAN receive                        |
| 7   | DIGITAL | D5     | INPUT     | Top fan RPM sensor                 |
| 8   | DIGITAL | D6     | INPUT     | Bottom fan RPM sensor              |
| 10  | DIGITAL | D8     | INPUT     | Flow switch                        |
| 11  | DIGITAL | D9     | OUTPUT    | Pump relay                         |
| 12  | DIGITAL | D10    | OUTPUT    | Expansion valve relay              |
| 13  | DIGITAL | D11    | OUTPUT    | Compressor relay                   |
| 14  | DIGITAL | D12    | OUTPUT    | Status lights/buzzer relay         |
| 21  | ANALOG  | A0     | INPUT     | Filter check diff. pressure sensor |
| 23  | DIGITAL | D16    | INPUT     | VL53L0X XSHUT input                |
| 24  | DIGITAL | D17    | INPUT     | VL53L0X GPIO1 input                |
| 25  | I2C     | SDA0   | BIDI      | Local I2C data                     |
| 26  | I2C     | SCL0   | BIDI      | Local I2C clock                    |
| 27  | DIGITAL | D20    | OUTPUT    | Fan PWM                            |
| 31  | POWER   | 3V3    |           | 3.3V output                        |
| 32  | POWER   | AGND   |           | Analog ground                      |
| 33  | POWER   | 5V     |           | 5V input from CAN                  |

### JST-XH Connectors

#### CAN
| Pin | Type  | Signal | Direction | Purpose           |
| --- | ----- | ------ | --------- | ----------------- |
| 1   | N/C   | N/C    |           |                   |
| 2   | CAN   | CAN H  | BIDI      | CAN Bus High      |
| 3   | CAN   | CAN L  | BIDI      | CAN Bus Low       |
| 4   | POWER | GND    |           | Digital ground    |
| 5   | POWER | 5V     |           | 5V from PCIe card |

#### I2C
| Pin | Type    | Signal | Direction | Purpose             |
| --- | ------- | ------ | --------- | ------------------- |
| 1   | POWER   | 3V3    |           | 3.3V output         |
| 2   | POWER   | GND    |           | Digital ground      |
| 3   | I2C     | SCL0   | BIDI      | Local I2C clock     |
| 4   | I2C     | SDA0   | BIDI      | Local I2C data      |
| 5   | DIGITAL | D17    | INPUT     | VL53L0X GPIO1 input |
| 6   | DIGITAL | D16    | INPUT     | VL53L0X XSHUT input |

#### Flow
| Pin | Type    | Signal | Direction | Purpose     |
| --- | ------- | ------ | --------- | ----------- |
| 1   | POWER   | 3V3    |           | 3.3V output |
| 2   | DIGITAL | D8     | INPUT     | Flow switch |

#### DS18B20 One-Wire
| Pin | Type   | Signal | Direction | Purpose        |
| --- | ------ | ------ | --------- | -------------- |
| 1   | 1-WIRE | D2     | BIDI      | DS18B20 bus    |
| 2   | POWER  | GND    |           | Digital ground |
| 3   | POWER  | 3V3    |           | 3.3V output    |

#### Filter Diff. Pressure
| Pin | Type   | Signal | Direction | Purpose                            |
| --- | ------ | ------ | --------- | ---------------------------------- |
| 1   | POWER  | 3V3    |           | 3.3V output                        |
| 2   | POWER  | GND    |           | Digital ground                     |
| 3   | ANALOG | A0     | INPUT     | Filter check diff. pressure sensor |

#### Fans
| Pin | Type    | Signal | Direction | Purpose               |
| --- | ------- | ------ | --------- | --------------------- |
| 1   | DIGITAL | D0     | INPUT     | Top fan RPM sensor    |
| 2   | DIGITAL | D1     | INPUT     | Bottom fan RPM sensor |
| 3   | DIGITAL | D5     | OUTPUT    | Fan PWM               |

#### Dual-Relay Module
| Pin | Type    | Signal | Direction | Purpose                    |
| --- | ------- | ------ | --------- | -------------------------- |
| 1   | POWER   | GND    |           | Digital ground             |
| 2   | DIGITAL | D11    | OUTPUT    | Status lights/buzzer relay |
| 3   | DIGITAL | D9     | OUTPUT    | Pump relay                 |
| 4   | POWER   | 5V     |           | 5V input from CAN          |

#### SSRs
| Pin | Type    | Signal | Direction | Purpose               |
| --- | ------- | ------ | --------- | --------------------- |
| 1   | POWER   | GND    |           | Digital ground        |
| 2   | DIGITAL | D11    | OUTPUT    | Compressor relay      |
| 3   | POWER   | GND    |           | Digital ground        |
| 4   | DIGITAL | D10    | OUTPUT    | Expansion valve relay |

### NF-A14 Control
* PWM: 40μs period, 5Vpp
* 8.76% minimum kickon => 468RPM (64ms/15.6Hz on tach.)
* 100% => 3180RPM (9.4ms/106.4Hz on tach.)

## KiCad design can_pcie_water_loop.kicad_pcb

Parts:
C1: 4700pF; C_1206_3216Metric
C2, C3: 0.1uF; C_1206_3216Metric
D1, D2, D3, D4, D5, D6: GREEN; LED_1206_3216Metric
D7: Ext T Stat; LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm
D8: Ext Flo Stat; LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm
D9: Int T Stat; LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm
D10: Int Flo Stat; LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm
H1, H2: PCIe Bracket; MountingHole_3.2mm_M3_Pad_Via
H3, H4, H5, H6: OLED; MountingHole_2.2mm_M2
H7: BME280; MountingHole_3.2mm_M3
J1: Bus_PCI_Express_x1; BUS_PCIexpress_x1
J2: CAN; DSUB-9_Female_Horizontal_P2.77x2.84mm_EdgePinOffset7.70mm_H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
J3: Int T Hi; PinHeader_1x02_P2.54mm_Horizontal
J4: Int T Lo; PinHeader_1x02_P2.54mm_Horizontal
J5: Ext T Hi; PinHeader_1x02_P2.54mm_Horizontal
J6: Ext T Lo; PinHeader_1x02_P2.54mm_Horizontal
J7: BME280 I2C; PinHeader_1x04_P2.54mm_Vertical
J8: Disp I2C; PinHeader_1x04_P2.54mm_Vertical
J9: Int Flo; PinHeader_1x03_P2.54mm_Horizontal
J10: Ext Flo; PinHeader_1x03_P2.54mm_Horizontal
J11: SW In; PinHeader_1x02_P2.54mm_Horizontal
J12: SW Out; PinHeader_1x02_P2.54mm_Horizontal
J13: SMBus; PinHeader_1x04_P2.54mm_Vertical
R1, R7, R8, R17, R18: 10k; R_1206_3216Metric
R2: 200; R_1206_3216Metric
R3, R4, R5, R6: 100k; R_1206_3216Metric
R9, R10: 60; R_1206_3216Metric
R11: 300; R_1206_3216Metric
R12, R13, R14, R15, R16: 220; R_1206_3216Metric
U1: Teensy3.2; Teensy30_31_32_All_Pins
U2: MCP2561; SOIC-8_3.9x4.9mm_P1.27mm
U3: CNY17-3; SMDIP-6_W7.62mm
U4: Pololu U3V16F5; PinHeader_1x03_P2.54mm_Vertical
U5: 74125; TSSOP-14_4.4x5mm_P0.65mm

Connections:
#PERST: J1.A11 (~PERST), R16.1, U1.8 (6_PWM)
+3.3V: J1.B10 (3.3Vaux), J7.1, J8.1, J9.1, J10.1, J13.1, R1.1, R3.1, R4.1, R5.1, R6.1, R7.1, R8.1, R12.1, R13.1, R14.1, R17.1, U1.31 (3.3V), U1.42 (3.3V), U4.1 (Vin), U5.12, U5.13
+5V: C2.1, C3.1, D7.1 (VDD), D8.1 (VDD), D9.1 (VDD), D10.1 (VDD), J2.9, R18.1, U2.3 (VDD), U4.3 (Vout), U5.14 (VCC)
/#PRSNT: J1.A1 (~PRSNT1), J1.B17 (~PRSNT2)
/CAN.RX: U1.6 (4_RX_PWM), U2.4 (RXD)
/CAN.STDBY: R18.2, U2.8 (STBY), U5.3
/CAN.TX: U2.1 (TXD), U5.6
/CAN_H: J2.7, R9.1, U2.7 (CANH)
/CAN_L: J2.2, R10.2, U2.6 (CANL)
/FP_PWR+: J12.1, U3.5
/FP_PWR-: J12.2, U3.4
EXT_FLOW: D1.1 (K), J10.2, R7.2, U1.3 (1_TX1_Touch)
EXT_TEMP_HI: J5.1, R5.2, U1.21 (14_A0_SCK)
EXT_TEMP_LO: J6.1, R6.2, U1.22 (15_A1_CS_Touch)
Earth: H1.1, H2.1, J2.0 (PAD), J2.5
FP_PWR_IN: D4.1 (K), J11.1, R1.2, U1.30 (23_A9_Touch_PWM)
FP_PWR_OUT: R2.2, U1.29 (22_A8_Touch_PWM)
GND: C1.1, C2.2, C3.2, D3.1 (K), D5.1 (K), D6.1 (K), D7.3 (VSS), D8.3 (VSS), D9.3 (VSS), D10.3 (VSS), J1.A4 (GND), J1.A12 (GND), J1.A15 (GND), J1.A18 (GND), J1.B4 (GND), J1.B7 (GND), J1.B13 (GND), J1.B16 (GND), J1.B18 (GND), J2.3, J2.6, J7.2, J8.2, J9.3, J10.3, J11.2, J13.2, U1.1 (GND), U1.53 (GND), U2.2 (VSS), U3.2, U4.2 (GND), U5.7 (GND)
GNDA: J3.2, J4.2, J5.2, J6.2, U1.32 (AGND)
I2C_SCL: J7.3, J8.3, U1.47 (29_A18_SCL1)
I2C_SDA: J7.4, J8.4, U1.46 (30_A19_SDA1)
INT_FLOW: D2.1 (K), J9.2, R8.2, U1.2 (0_RX1_Touch)
INT_TEMP_HI: J3.1, R3.2, U1.23 (16_A2_SCL0_Touch)
INT_TEMP_LO: J4.1, R4.2, U1.24 (17_A3_SDA0_Touch)
unnamed: C1.2, R9.2, R10.1, R11.1
unnamed: D1.2 (A), R12.2
unnamed: D2.2 (A), R13.2
unnamed: D3.2 (A), R2.1, U3.1
unnamed: D4.2 (A), R14.2
unnamed: D5.2 (A), R15.2
unnamed: D6.2 (A), R16.2
unnamed: D7.4 (DIN), U5.8
unnamed: D7.2 (DOUT), D8.4 (DIN)
unnamed: D8.2 (DOUT), D9.4 (DIN)
unnamed: D9.2 (DOUT), D10.4 (DIN)
unnamed: R15.1, U1.4 (2), U5.2
unnamed: U1.5 (3_TX_PWM), U5.5
unnamed: R17.2, U1.7 (5_TX1_PWM), U5.1, U5.4, U5.10
unnamed: U1.9 (7_RX3_DOUT), U5.9
unnamed: R11.2, U2.5 (SPLIT)
SMCLK: J1.B5 (SMCLK), J13.3, U1.26 (19_A5_SCL0_Touch)
SMDAT: J1.B6 (SMDAT), J13.4, U1.25 (18_A4_SDA0_Touch)

Board: 4 copper layers, 75.0 x 67.7 mm, 56 parts (19 on the bottom side), 42 nets.

## Code that names these connections

File firmware/CAN SMBus Water Cooling Loop Controller/src/main.cpp (part):

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#include <Thermistor.h>
#include <NTC_Thermistor.h>

#define INT_FLOW 0      // INPUT Internal loop flow sensor
#define EXT_FLOW 1      // INPUT External loop flow sensor
#define LS_OE 5         // OUTPUT Level shifter output enable, active low
#define PERST 6         // INPUT PCIe #PERST status
#define FP_PWR_OUT 22   // OUTPUT Front panel power switch output
#define FP_PWR_IN 23    // INPUT Front panel power switch input
#define EXT_OUT_TEMP A0 // External loop outflow temperature, 10k NTC
#define EXT_IN_TEMP A1  // External loop inflow temperature, 10k NTC
#define INT_IN_TEMP A2  // Internal loop inflow temperature, 10k NTC
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#define WS2811B 7       // OUTPUT WS2811B data
#define SMBUS_SDA 18    // SMBus I2C data
#define SMBUS_SCL 19    // SMBus I2C clock
#define I2C_SDA 30      // Local I2C data
#define I2C_SCL 29      // Local I2C clock
#define CAN_STDBY 2     // OUTPUT CAN standby, active high
#define CAN_TX 3        // CAN transmit
#define CAN_RX 4        // CAN receive
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
void setup()
{
    pinMode(FP_PWR_IN, INPUT_PULLUP);
    pinMode(PERST, INPUT_PULLUP);
    pinMode(LS_OE, OUTPUT);
    pinMode(CAN_STDBY, OUTPUT);
    pinMode(13, OUTPUT);
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
## Commit log

2023-08-19 Initial PCIe card design.
2023-08-19 Updated I2C silk.
2023-08-24 Placed DE-9 connector and bracket holes to close #1
2023-08-24 Initial firmware directory.
2023-08-25 Test bench build for monitoring.
2023-08-26 Updated to display data on screen.
2023-09-06 CW-5200 Supporting files
2023-09-06 Testing data for distance sensors
2023-09-07 Support hardware
2023-09-08 Reservoir level sensor hardware
2023-09-08 Attempt to fix CP437/UTF-8 symbols for OLED vs file encoding
2023-09-08 Initial standalone chiller control code
2023-09-08 Bugfixes.
2023-09-21 Fixed polarity for SSRs
2023-09-22 Updated README for pinouts.
2023-09-22 Properly fixed valve/SSR control
2023-10-04 Updated fan pins to fix RPM and PWM issues.
2023-10-05 Laying groundwork for CAN control/monitoring
2025-06-12 Added library for Honeywell ABP2 sensor
